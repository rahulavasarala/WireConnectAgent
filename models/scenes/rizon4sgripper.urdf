Commit message: Added ZMQ joint server + parallel continuous action space mujoco + opensai training

File: models/scenes/rizon4sgripper.urdf (robot description, URDF)
Before this commit: robot rizon4s, 20 links, 19 joints
Links:
- link robotiq_arg2f_base_link: mass 0.22652 -> 0.777441
